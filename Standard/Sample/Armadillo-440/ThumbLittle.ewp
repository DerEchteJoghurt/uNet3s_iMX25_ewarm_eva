# IAR project ThumbLittle.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX25 Freescale MCIMX25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Kernel\inc; ..\..\Kernel\inc\ARMv5T; ..\..\Driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  ILINK.IlinkOutputFile: ThumbLittle.out
  ILINK.IlinkIcfFile: Armadillo-440.icf
  ILINK.IlinkAdditionalLibs: ..\..\Kernel\lib\uC3thmv5tl.a
  ILINK.IlinkProgramEntryLabel: _PRST
configuration Flash (ARM, debug)
  as the first configuration, except:
  group (top)
    ../../Driver/src/: DDR_ARM926_MMU.s79 DDR_COM.c DDR_FS_MX25ASIC.c DDR_FS_MX25EPIT.c DDR_FS_MX25UART.c
    ./: main.c prstmx25.s79
