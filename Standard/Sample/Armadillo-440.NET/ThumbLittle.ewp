# IAR project ThumbLittle.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX25 Freescale MCIMX25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Kernel\inc; ..\..\Kernel\inc\ARMv5T; ..\..\Driver\inc; ..\..\Network\inc; ..\..\Network\NetApp; ..\..\Network\sample
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: ThumbLittle.srec
  ILINK.IlinkOutputFile: ThumbLittle.out
  ILINK.IlinkIcfFile: Armadillo-440.icf
  ILINK.IlinkAdditionalLibs: ..\..\Kernel\lib\uC3thmv5tl.a; ..\..\Network\lib\uNet3thmv5tl.a
  ILINK.IlinkProgramEntryLabel: _PRST
configuration Flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 2
  group (top)
    ./: main.c prstmx25.s79 Readme.txt sample_app.c
  group Driver
    ../../Driver/src/: DDR_ARM926_MMU.s79 DDR_COM.c DDR_FS_MX25ASIC.c DDR_FS_MX25EPIT.c DDR_FS_MX25UART.c
  group Network
    ./: cgi_sample.c net.c net_cfg.c shell_cfg.c
  group Network/sample
    ../../Network/sample/: shell.c
